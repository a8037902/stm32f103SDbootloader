# Keil uVision project Demo.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\User\inc;..\..\Librarise\CORE;..\..\Librarise\STM32F10x_FWLib\inc;..\..\UCOSII\CONFIG;..\..\UCOSII\CORE;..\..\UCOSII\PORT;..\..\SYSTEM\inc;..\..\HARDWARE\inc;..\..\FATFS\src
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT5: ROM 0x8008000 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../../User/src/: main.c stm32f10x_it.c system_stm32f10x.c tool.c FlashEncode.c DES.c
    ../../User/inc/: config.h
  group CORE
    ../../Librarise/CORE/: core_cm3.c startup_stm32f10x_md.s
  group SYSTEM
    ../../SYSTEM/src/: delay.c sys.c usart.c
    ../../SYSTEM/inc/: stm32sys_cfg.h
  group FWLIB
    ../../Librarise/STM32F10x_FWLib/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_spi.c
  group HARDWARE
    ../../HARDWARE/src/: mmc_sd.c spi.c SD.c 74hc595.c
  group FATFS
    ../../FATFS/src/: diskio.c ff.c ffconf.h
